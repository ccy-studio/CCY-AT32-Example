# Keil uVision project AT32F403ACGT7_Test.uvprojx, settings and files
target AT32F403ACGT7_Test (6210000::V6.21::ARMCLANG)
  device: -AT32F403ACGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.7
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32F403ACGT7_Test +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F403ACGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1,EXTEND_SRAM=0xFE
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\middlewares\freertos\Source\include;..\..\middlewares\freertos\Source\portable\GCC\ARM_CM4F;..\..\middlewares\3rd_party\fatfs\source
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8400000 size 0x1000000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: main.c at32f403a_407_wk_config.c at32f403a_407_int.c at32_sys.c user_service.c at32_sdio.c diskio.c run_in_spim.c
  group firmware
    ../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_debug.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_sdio.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_dma.c
  group cmsis
    ./: startup_at32f403a_407.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group freertos
    ../../middlewares/freertos/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../middlewares/freertos/Source/portable/MemMang/: heap_4.c
    ../../middlewares/freertos/Source/portable/GCC/ARM_CM4F/: port.c
  group ftsfs
    ../../middlewares/3rd_party/fatfs/source/: ff.c ffsystem.c ffunicode.c
